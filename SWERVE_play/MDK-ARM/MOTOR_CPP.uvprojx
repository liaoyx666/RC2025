# Keil uVision project MOTOR_CPP.uvprojx, settings and files
target MOTOR_CPP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MOTOR_CPP +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../GDUTRCLIB/BSP/Inc;../GDUTRCLIB/Components/Inc;../GDUTRCLIB/Module/Inc;../Task/Comm/Inc;../Task/User/Inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group GDUTRCLIB/BSP
    ../GDUTRCLIB/BSP/Src/: drive_can.c drive_iic.c drive_tim.c drive_uart.c drive_exti.c
  group GDUTRCLIB/Components
    ../GDUTRCLIB/Components/Src/: filter.cpp pid.cpp speed_plan.cpp tool.cpp dribble_ball.cpp shoot.cpp path_tracing.cpp
    ../GDUTRCLIB/Components/Inc/: pid.h motor.h tool.h dribble_ball.h shoot.h path_tracing.h
    ../GDUTRCLIB/BSP/Inc/: action.h LaserPositioning.h
    ../GDUTRCLIB/BSP/Src/: action.c LaserPositioning.c
  group GDUTRCLIB/Module
    ../GDUTRCLIB/Module/Src/: air_joy.cpp omni_chassis.cpp chassis_swerve.cpp chassis_base.cpp launcher.cpp
  group Task/Comm
    ../Task/Comm/Src/: data_pool.cpp service_config.cpp service_communication.cpp user_debug.cpp
  group Task/User
    ../Task/User/Src/: chassis_task.cpp fsm_joy.cpp location_task.cpp
    ../Task/User/Inc/: location_task.h
software components: CMSIS:CORE 6.1.0
